# Repository wjwpoi/DaisySeedProjects

File README.md:

# Daisy Seed Projects

当前开发方向：[ToneDock 桌面 NAM 软件效果器](ToneDock/README.md)，面向 Windows / macOS 的独立软件与 VST3 / AU 插件，包含模型库、TONE3000 导入与可编辑效果链。[SeedFX 硬件方案](SeedFX/README.md) 自 2026-10-15 起暂缓，保留已有工程，不进入采购。

This is a demo of a pedal board I put together using 3 of my custom Daisy Seed based guitar pedals. I designed and built the hardware and programmed the software. Everything shown here is open source and all the code, pcb files, and basic instructions on how to build the pedals, can be found on these pages.

## Software Projects:
### 1. [Guitar Multi-Effect Pedal](Software/GuitarPedal/README.md)
The software that can run on any of the custom Guitar Pedal hardware projects listed below as well at the PedalPCB Terrarium hardware.  This software is a flexible platform that abstracts the underlying Guitar Pedal hardware and allows a collection of Effects Modules to run on any of those hardware platforms.

## Hardware Projects:

I provide everything you need to build any of pedals you see below along with pretty detailed documentation.  However, recently I started to get a lot of requests to buy kits or finished pedals based on my designs. This is not something I typically do, but sometimes I do have extra PCBs, parts, and enclosures lying around and I'm willing to pass them along to you, basically at cost. I've included some ordering details along with each design below.

### 1. [Guitar Effect Pedal in 125b Enclosure](Hardware/GuitarPedal125b/README.md) (SMD Parts)
A feature rich and flexible platform for making DSP based guitar FX pedals. Stereo Audio, Midi in/out, OLED Display, Rotary Encoder for Menu Navigation, 6 Knobs, 2 LEDs, 2 Foot Switches, Relay based "True Bypass" switching, all based on the Daisy Seed microcontroller.

[Ordering Information](Hardware/GuitarPedal125b/docs/OrderingHardware.md)

### 2. [Guitar Effect Pedal in 1590b Enclosure](Hardware/GuitarPedal1590b-SMD/README.md) (SMD Parts)

A robust and tiny platform for making DSP based guitar FX pedals. Stereo Audio, Midi in/out, 4 Knobs, 2 LEDs, 1 or 2 Foot Switches, Relay based "True Bypass" switching, all based on the Daisy Seed microcontroller. Using SMD parts for easy manufacturing by a fab such as JLCPCB.

[Ordering Information](Hardware/GuitarPedal1590b-SMD/docs/OrderingHardware.md)

### 3. [Guitar Effect Pedal in 1590b Enclosure](Hardware/GuitarPedal1590b/README.md) (Through-hole parts)

Same form factor and features as the SMD version of the 1590b pedal, minus the Relay based "True Bypass" switching. Using all Through-Hole parts for easy assembly at home with limited soldering skills.

[Ordering Information](Hardware/GuitarPedal1590b/docs/OrderingHardware.md)

More Information about the Daisy Seed can be found at:

http://electro-smith.com

## KiCad design SeedFX/hardware/adapter/seedfx-adapter.kicad_pcb

File SeedFX/README.md:

# SeedFX：NAM A2 综合效果器

本项目目标是制作 **一台自用综合效果器**；组装调试和最终使用均由同一台设备完成。基于本 fork 的 **完整可构建工程** 包含：音频固件、ESP32 无线固件、手机网页、两块 PCB 工程与制作文件、BOM、外壳 CAD、封面模板和验收说明。实机音质、端到端延迟、无线噪声、温升和器件装配公差在这同一台设备上验证；完成调试与验收后即为最终成品。

首版采用 Daisy Seed Rev7、XIAO ESP32-C3、六旋钮、一个按压编码器、两个脚踏、0.96 英寸 128×64 SPI OLED 和 125B 面板尺寸、含增高隔圈深度 42mm 的外壳。屏幕按参考主板的实际封装选型；模型名与调音读数采用大字体，详细编辑在手机页面完成。

音频链为：**输入 → 噪声门 → 压缩 → 过载 → NAM → 三段 EQ → 箱体 IR → 合唱 → 延迟 → 混响 → 输出**，另有调音器和数字旁通。音频始终在 Daisy 本机运行；Wi-Fi 用于参数、旋钮映射和预设控制。

## 采购状态

当前软件与工程文件可构建，采购前复核尚未全部关闭。完整器件装配、公差、供应商壳体与报价仍需确认；目前可先准备指定型号的两块主控采购，PCB 装配和最终壳体加工待复核后下单，见 [采购前复核](docs/PROCUREMENT_READINESS.md)。

## 从这里开始

| 内容 | 文件 |
|---|---|
| 打包内容与恢复工程 | [交付指南](docs/RELEASE.md)、[文件校验清单](releases/manifest.json) |
| 产品范围、架构和设计指标 | [产品设计](docs/PRODUCT.md) |
| 采购和生产 | [硬件与装配](docs/HARDWARE.md)、[采购 BOM](hardware/purchase-bom.csv)、[逐项预估价](docs/PURCHASING_PRICES.md)、[连接表](hardware/wiring.csv) |
| PCB 源文件 | [主板](hardware/mainboard/DaisySeedPedal125b.kicad_pcb)、[无线适配板](hardware/adapter/seedfx-adapter.kicad_pcb) |
| 原理图源文件 | [主板](hardware/mainboard/DaisySeedPedal125b.kicad_sch)、[无线适配板](hardware/adapter/seedfx-adapter.kicad_sch) |
| 外壳与封面 | [装配 STEP](mechanical/seedfx-enclosure.step)、[开孔 DXF](mechanical/front-drill.dxf)、[印刷版](mechanical/panel-print.svg)、[自定义封面模板](mechanical/panel-artwork-template.svg) |
| 编译与烧录 | [构建指南](docs/BUILD.md) |
| 串口、HTTP 与存储接口 | [协议说明](docs/PROTOCOL.md)、[GPIO 对照](hardware/io-map.csv) |
| 操作 | [用户手册](docs/USER_MANUAL.md) |
| NAM 导入边界 | [模型指南](docs/MODELS.md) |
| 已执行检查与单台成品验收 | [验证说明](docs/VALIDATION.md)、[机器报告](docs/validation.json) |
| 默认封面外观 | [面板预览](docs/images/panel-preview.png)，图中的圆圈为硬件避让位置 |
| 手机页面外观 | [手机预览](docs/images/web-mobile.png)、[桌面预览](docs/images/web-desktop.png)；预览明确使用模拟状态，CPU/音频数据未实测 |

## 已实现的关键行为

- 内置五个参考模型、两个 1024 点箱体 IR、16 个可保存预设和六旋钮自定义映射。
- 旋钮支持软接管；缓慢旋转也能累计生效。启动前一秒只等待 ADC 稳定，避免覆盖保存的参数。
- 连续参数平滑；模型、IR 和效果开关通过淡出、主循环配置、淡入完成切换。音频中断不做文件操作、网络请求、闪存擦写或动态分配。
- 新增解析稳态初始化：与原 133 块预热在五个模型、15,360 个后续样本上对比，最大绝对误差约 `8.64e-7`。实际换模耗时须在 Daisy 上测量。
- 预设双区 CRC 日志，保留上一个有效银行；保存确认在写入并读回验证后才返回。重启恢复上次显式保存的槽位。
- UART 使用 COBS、CRC32、范围检查、ACK 和启动会话握手；无线失联时网页禁用控制，本机旋钮和音频继续工作。

## 成本与边界

相对原仓库的沿用成本、新增无线与制作费用拆分见 [成本来源对比](docs/COST_COMPARISON.md)。当前未证明这条单台 DIY 路线比市售成品便宜。

当前制作方向改为自行焊接、淘宝通用铝壳或 PETG 打印壳、简单贴纸封面。用户需要从零购置工具：全手焊加通用铝壳、外包开孔，整项目预留 **¥833.9–1801.5**；全手焊加打印壳预留 **¥778.9–1636.5**。两者均含 ¥180–350 的基础工具与练习耗材、外接 9V 电源、运费及小料采购补差，详见 [手焊与通用外壳预算](docs/DIY_BUILD_OPTIONS.md)。当前外壳 CAD 仍是尺寸参考，实际铝壳内腔和打印壳承重设计待确认。

此前委托焊接、壳体加工及 UV 印刷路线 **¥848.9–2006.5** 保留为 [分项对照表](docs/PURCHASING_PRICES.md)，不能与新路线费用叠加。所有价格仍为工程预估，未经实时询价；全部起步费和最低采购量由这一个项目承担，多余裸板作为维修备件。默认选用上电标定并锁定到 5V 的通用 Mini-360 电源模块；希望使用固定输出品牌件时可换 Pololu D24V10F5。

首版为单声道、外接 9V、Wi-Fi 网页控制。采用参考主板的 TRS 接口时，正常使用 mono TS 线，DSP 模式下 Ring 输出为零信号。没有耳机驱动、电池、蓝牙控制、无线音频或 OTA 功能。

原仓库应用与原始硬件文件保持作为参考；本项目的工作集中在 `SeedFX/`。源代码与 KiCad 库的出处见 [第三方说明](THIRD_PARTY.md)。

Parts:
C1, C2: 22u 10V X5R; C_1206_3216Metric
C3: 100n 50V X7R; C_0805_2012Metric
FB1: BLM21PG601SN1D; L_0805_2012Metric
H1, H2: M2 NPTH; MountingHole_2.2mm_M2
J1: 5V BUCK INPUT; PinHeader_1x02_P2.54mm_Vertical
J2: XIAO HARNESS; PinHeader_1x04_P2.54mm_Vertical
J3: DAISY HARNESS; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 1k 1%; R_0805_2012Metric

Connections:
/5V_SOURCE: FB1.1, J1.1
/5V_WIFI: C1.1, C2.1, C3.1, FB1.2, J2.1
/ESP_RX: J2.4, R1.2
/ESP_TX: J2.3, R2.1
/GND: C1.2, C2.2, C3.2, J1.2, J2.2, J3.1
/SEED_RX: J3.3, R2.2
/SEED_TX: J3.2, R1.1

Board: 2 copper layers, 32.0 x 28.0 mm, 11 parts (0 on the bottom side), 7 nets.

File SeedFX/hardware/adapter/bom.csv:

Reference,Value,Footprint,Quantity
J1,5V BUCK INPUT,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,1
J2,XIAO HARNESS,Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical,1
J3,DAISY HARNESS,Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical,1
FB1,BLM21PG601SN1D,Inductor_SMD:L_0805_2012Metric,1
C1,22u 10V X5R,Capacitor_SMD:C_1206_3216Metric,1
C2,22u 10V X5R,Capacitor_SMD:C_1206_3216Metric,1
C3,100n 50V X7R,Capacitor_SMD:C_0805_2012Metric,1
R1,1k 1%,Resistor_SMD:R_0805_2012Metric,1
R2,1k 1%,Resistor_SMD:R_0805_2012Metric,1

## KiCad design SeedFX/hardware/mainboard/DaisySeedPedal125b.kicad_pcb

Board: 4 copper layers, 60.0 x 94.0 mm, 80 parts (12 on the bottom side), 66 nets.

Parts:
C1, C4, C7, C8, C11, C12, C15, C16: 10UF; C_0805_2012Metric
C2, C3, C5, C6, C13, C14, C17: 100NF; C_0805_2012Metric
C9, C10: 2.2NF; C_0805_2012Metric
C18, C19: 10NF; C_0805_2012Metric
D1: 1N5817; D_SOD-123
D2: 1N4148; D_SOD-123
D3, D4: 1N4007; D_SOD-123F
ENC1: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
FS1: Foot_Switch_1; PinHeader_1x02_P2.54mm_Vertical
FS2: Foot_Switch_2; PinHeader_1x02_P2.54mm_Vertical
J1: Barrel_Jack_Switch; Generic_PowerJack
J2: AUDIO_IN_TRS; NEUTRIK_NMJ6HCD2
J3: MIDI IN JACK; PJ-320A
J4: AUDIO_OUT_TRS; NEUTRIK_NMJ6HCD2
J5: MIDI OUT JACK; PJ-320A
J6, J7: Conn_01x20_Socket; PinSocket1x20_P2.54mm_Vertical_JLCPCB
K1, K2: G6K-2; Relay_DPDT_Omron_G6K-2G-Y
LED1: LED_1; PinHeader_1x02_P2.54mm_Vertical
LED2: LED_2; PinHeader_1x02_P2.54mm_Vertical
POT1, POT2, POT3, POT4, POT5, POT6: 10K; Potentiometer_Bourns_PRS11R
Q1: SS8050; SOT-23-3
R1, R2, R4, R5, R9, R10, R11, R12, R15, R16: 2M; R_0805_2012Metric
R3, R6: 100K; R_0805_2012Metric
R7, R8: 3.3K; R_0805_2012Metric
R13, R14: 100R; R_0805_2012Metric
R17: 220R; R_0805_2012Metric
R18: 10R; R_0805_2012Metric
R19: 33R; R_0805_2012Metric
R20: 470R; R_0805_2012Metric
R21, R22, R23, R24, R25: 1K; R_0805_2012Metric
R26, R27, R28, R29: 10K; R_0805_2012Metric
U1: LD1117S50TR_SOT223; SOT-223-3_TabPin2
U2: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm
U3: OPA1652AID; SOIC-8_3.9x4.9mm_P1.27mm
U4: H11L1; SOP-6_2.54mm
U5, U6: CPC1018N; SOP-4_3.8x4.1mm_P2.54mm
U7: OLED_DISPLAY_SSD1306_SPI; HiLetgo_OLED_SPI

Connections:
+3.3V: C17.1, J6.3, R19.2, R20.1, R28.1, R29.2, U4.6, U7.2 (VCC)
+3.3VA: J6.20, POT1.3, POT2.3, POT3.3, POT4.3, POT5.3, POT6.3
+5V: C4.1, C5.1, C6.1, C13.1, C14.1, D3.1 (K), D4.1 (K), K1.1, K2.1, R3.1, R9.1, R11.1, U1.2 (VO), U2.4 (V+), U3.8 (V+)
+9V: C1.1, C2.1, C3.1, D1.1 (K), J6.2, U1.3 (VI)
/Audio Input Buffer/V_AUDIOBIAS: R4.1, R5.1, U2.1, U2.2 (-)
AUDIO_IN_BUFFER_LEFT: J7.5, U2.13 (-), U2.14
AUDIO_IN_BUFFER_RIGHT: J7.4, U2.8, U2.9 (-)
AUDIO_IN_JACK_LEFT: J2.T, K1.4, K1.7
AUDIO_IN_JACK_RIGHT: J2.R, K2.4, K2.7
AUDIO_OUT_BUFFER_LEFT: J7.3, R7.1
AUDIO_OUT_BUFFER_RIGHT: J7.2, R8.1
AUDIO_OUT_JACK_LEFT: J4.T, K1.6, U5.4
AUDIO_OUT_JACK_RIGHT: J4.R, K2.6, U6.4
BYPASS_LEFT_RETURN: C15.2, K1.5, R15.1
BYPASS_LEFT_SEND: C7.1, K1.3, R1.1
BYPASS_RIGHT_RETURN: C16.2, K2.5, R16.1
BYPASS_RIGHT_SEND: C8.1, K2.3, R2.1
DISABLE_AUDIO_BYPASS: J7.19, R21.1
ENABLE_AUDIO_MUTE: J7.8, R22.1, R23.1
ENCODER_1_A: C18.1, J7.18, R26.1
ENCODER_1_B: C19.2, J7.17, R27.2
ENCODER_1_CLICK: ENC1.S1, J7.16
FOOT_SWITCH_1: FS1.2, J7.14
FOOT_SWITCH_2: FS2.2, J7.15
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C13.2, C14.2, C17.2, C18.2, C19.1, ENC1.C, ENC1.S2, FS1.1, FS2.1, J1.1, J1.3, J2.RN, J2.S, J2.SN, J2.TN, J3.S, J4.RN, J4.S, J4.SN, J4.TN, J5.S, J6.1, J7.1, K1.2, K2.2, LED1.1 (K), LED2.1 (K), POT1.1, POT2.1, POT3.1, POT4.1, POT5.1, POT6.1, Q1.2 (E), R1.2, R2.2, R6.2, R10.2, R12.2, R15.2, R16.2, U1.1 (GND), U2.5 (+), U2.11 (V-), U3.4 (V-), U4.5, U5.2, U5.3, U6.2, U6.3, U7.1 (GND)
LED_1: J6.12, R24.2
LED_2: J6.11, R25.2
MIDI_IN: J6.4, R20.2, U4.4
MIDI_IN_JACK_PIN4: J3.R1, R17.1
MIDI_IN_JACK_PIN5: D2.2 (A), J3.T, U4.2
MIDI_OUT: J6.5, R18.2
MIDI_OUT_JACK_PIN4: J5.R1, R19.1
MIDI_OUT_JACK_PIN5: J5.T, R18.1
unnamed: C10.1, C12.2, R8.2
unnamed: C9.1, C11.2, R7.2
unnamed: C15.1, R13.2
unnamed: C16.1, R14.2
unnamed: D2.1 (K), R17.2, U4.1
unnamed: D3.2 (A), D4.2 (A), K1.8, K2.8, Q1.3 (C)
unnamed: ENC1.A, R26.2, R28.2
unnamed: ENC1.B, R27.1, R29.1
unnamed: LED1.2 (A), R24.1
unnamed: LED2.2 (A), R25.1
unnamed: Q1.1 (B), R21.2
unnamed: R22.2, U5.1
unnamed: R23.2, U6.1
unnamed: R3.2, R6.1, U2.3 (+)
unnamed: U2.6 (-), U2.7
unnamed: C8.2, R5.2, U2.10 (+)
unnamed: C7.2, R4.2, U2.12 (+)
unnamed: C12.1, R11.2, R12.1, U3.3 (+)
unnamed: R14.1, U3.1, U3.2 (-)
unnamed: C11.1, R9.2, R10.1, U3.5 (+)
unnamed: R13.1, U3.6 (-), U3.7
OLED_DISPLAY_SPI_CS: J7.13, U7.7 (CS)
OLED_DISPLAY_SPI_DC: J7.11, U7.6 (DC)
OLED_DISPLAY_SPI_MOSI: J7.10, U7.4 (D1)
OLED_DISPLAY_SPI_RESET: J7.9, U7.5 (RES)
OLED_DISPLAY_SPI_SCK: J7.12, U7.3 (D0)
POT_1: J6.19, POT1.2
POT_2: J6.18, POT2.2
POT_3: J6.17, POT3.2
POT_4: J6.16, POT4.2
POT_5: J6.15, POT5.2
POT_6: J6.14, POT6.2
POWER_JACK_PWR: D1.2 (A), J1.2

## Code that names these connections

File SeedFX/tools/hardware.py (part):

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        n=pcb.NETINFO_ITEM(b,"/"+name);b.Add(n);nets[name]=n
    parts=[
      dict(ref='J1',value='5V BUCK INPUT',lib='Connector_Generic',symbol='Conn_01x02',footprint='Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical',x=4,y=4,sx=35,sy=35,nets={'1':'5V_SOURCE','2':'GND'}),
      dict(ref='J2',value='XIAO HARNESS',lib='Connector_Generic',symbol='Conn_01x04',footprint='Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical',x=4,y=15,sx=35,sy=85,nets={'1':'5V_WIFI','2':'GND','3':'ESP_TX','4':'ESP_RX'}),
      dict(ref='J3',value='DAISY HARNESS',lib='Connector_Generic',symbol='Conn_01x03',footprint='Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical',x=26,y=18,sx=120,sy=85,nets={'1':'GND','2':'SEED_TX','3':'SEED_RX'}),
      dict(ref='FB1',value='BLM21PG601SN1D',lib='Device',symbol='FerriteBead',footprint='Inductor_SMD:L_0805_2012Metric',x=13,y=4,sx=85,sy=35,nets={'1':'5V_SOURCE','2':'5V_WIFI'}),
      dict(ref='C1',value='22u 10V X5R',lib='Device',symbol='C',footprint='Capacitor_SMD:C_1206_3216Metric',x=20,y=8,sx=130,sy=35,nets={'1':'5V_WIFI','2':'GND'}),
      dict(ref='C2',value='22u 10V X5R',lib='Device',symbol='C',footprint='Capacitor_SMD:C_1206_3216Metric',x=13,y=10,sx=175,sy=35,nets={'1':'5V_WIFI','2':'GND'}),
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